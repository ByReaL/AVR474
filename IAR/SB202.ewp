# IAR project SB202.ewp, settings and files
configuration SB202-2 Debug (AVR, debug)
  General.LCHeapSize: 0x20
  General.SCCStackSize: 0x50
  General.SCRStackSize: 40
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: SB202_2
  ICCAVR.newCCIncludePaths: ; conf\; lib_board\; lib_board\bandgap\; lib_board\v_adc\; lib_board\cc-adc\; lib_board\battery_protection\; lib_board\watchdog\; lib_board\fet_control\; lib_board\rc_calibration\; lib_board\sw_uart\; lib_board\vreg_mon\; lib_mcu\; lib_mcu\timer\; lib_MCU\battery_pack_parameters\; lib_mcu\sbs_commands\; lib_mcu\battery_voltage_monitoring\; lib_mcu\battery_current_monitoring\; lib_mcu\power_management\; lib_mcu\authentication\; lib_mcu\ntc_rh163h103f\; lib_mcu\rtc\; lib_mcu\gas_gauging\; lib_mcu\voltage_based_SoC\; lib_mcu\crc; lib_mcu\sm_bus\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm32hvb.xcl
configuration SB202-3 Debug (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: SB202_3
  ICCAVR.newCCIncludePaths: ; conf\; lib_board\; lib_board\bandgap\; lib_board\v_adc\; lib_board\cc-adc\; lib_board\battery_protection\; lib_board\watchdog\; lib_board\fet_control\; lib_board\rc_calibration\; lib_board\sw_uart\; lib_board\vreg_mon\; lib_mcu\; lib_mcu\communication\; lib_MCU\battery_pack_parameters\; lib_mcu\sbs_commands\; lib_mcu\battery_voltage_monitoring\; lib_mcu\battery_current_monitoring\; lib_mcu\power_management\; lib_mcu\authentication\; lib_mcu\ntc_rh163h103f\; lib_mcu\rtc\; lib_mcu\gas_gauging\; lib_mcu\voltage_based_SoC\; lib_mcu\crc; lib_mcu\sm_bus; lib_mcu\timer
configuration SB202-4 Debug (AVR, debug)
  as the first configuration, except:
  ICCAVR.CCDefines: SB202_4
configuration SB202-2 Release (AVR)
  as the first configuration, except:
  ICCAVR.newCCIncludePaths: ; conf\; lib_board\; lib_board\bandgap\; lib_board\v_adc\; lib_board\cc-adc\; lib_board\battery_protection\; lib_board\watchdog\; lib_board\fet_control\; lib_board\rc_calibration\; lib_board\sw_uart\; lib_board\vreg_mon\; lib_mcu\; lib_mcu\communication\; lib_MCU\battery_pack_parameters\; lib_mcu\sbs_commands\; lib_mcu\battery_voltage_monitoring\; lib_mcu\battery_current_monitoring\; lib_mcu\power_management\; lib_mcu\authentication\; lib_mcu\ntc_rh163h103f\; lib_mcu\rtc\; lib_mcu\gas_gauging\; lib_mcu\voltage_based_SoC\; lib_mcu\crc; lib_mcu\sm_bus\; lib_mcu\timer\
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$-2_eeprom.hex
configuration SB202-3 Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: SB202_3
  ICCAVR.newCCIncludePaths: as above
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$-3_eeprom.hex
configuration SB202-4 Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: SB202_4
  ICCAVR.newCCIncludePaths: as above
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$-4_eeprom.hex
  group (top)
    lib_mcu/authentication/aes/: aes_lib.c
    conf/: asm_functions.s90
    lib_mcu/authentication/: authentication.c
    lib_board/bandgap/: bandgap.c
    lib_mcu/Battery_current_monitoring/: battery_current_monitoring.c
    lib_mcu/battery_pack_parameters/: battery_pack_parameters.c
    lib_board/battery_protection/: battery_protection.c
    lib_mcu/battery_voltage_monitoring/: battery_voltage_monitoring.c
    lib_mcu/gas_gauging/: cc_gas_gauging.c gas_gauging.c
    lib_board/cc-adc/: ccadc.c
    lib_mcu/crc/: crc16.c crc8.c
    lib_board/fet_control/: fet_control.c
    lib_mcu/authentication/HMAC-SHA2/: HMAC-SHA2.c
    ./: main.c
    lib_mcu/ntc_RH163H103F/: ntc_rh163h103f.c
    lib_board/rc_calibration/: rc_calibration.c
    lib_mcu/rtc/: rtc.c
    lib_mcu/sm_bus/: smbus.c
    lib_mcu/timer/: timer.c
    lib_board/v_adc/: vadc.c
    lib_mcu/voltage_based_SoC/: voltage_based_SoC.c
    lib_board/vreg_mon/: vreg_mon.c
    lib_board/watchdog/: watchdog.c
